# Keil uVision project Template.uvproj, settings and files
target Source (MCS-251)
  device: STC32G12K128 Series STC
  cpu: IRAM(0-0xFFF) XRAM(0x10000-0x11FFF) IROM(0xFE0000-0xFFFFFF) CLOCK(35000000)
  output: Template +hex
  group Main
    ../../App/Main/: main.c
  group Bsp
    ../../Bsp/: bsp_led.c bsp_systick.c
  group Library
    ../../Library/: STC32G_GPIO.c
